# Keil uVision project GD32FreeRTOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F330C8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.1.0.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: GD32FreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F3X0,GD32F330
  c include: ../Firmware/CMSIS;../Firmware/CMSIS/GD/GD32F3x0/Include;../Firmware/GD32F3x0_standard_peripheral/Include;../Main;../Driver/include;../FreeRTOS/Source/include;../FreeRTOS/Source/portable;../bsp;../
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group FirmwareCMSIS
    ../Firmware/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
    ../Firmware/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group FirmwareLib
    ../Firmware/GD32F3x0_standard_peripheral/Source/: gd32f3x0_gpio.c gd32f3x0_rcu.c gd32f3x0_syscfg.c
  group BSP
    ../BSP/: bsp.c
  group Driver
    ../Driver/source/: led.c
  group FreeRTOSPort
    ../FreeRTOS/Source/portable/: port.c
  group FreeRTOS
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c heap_2.c
  group Main
    ../Main/: gd32f3x0_it.c systick.c main.c
